# IAR project VirtualCom.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: EMB_FLASH
  ICCARM.CCIncludePath2: ; app\; board\; module\; ..\library\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: VirtualCom.out
  ILINK.IlinkIcfFile: config\STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    app/: main.c
  group HD44780
    module/: drv_hd44780.c drv_hd44780_cnfg.h drv_hd44780_l.c
  group Other
    VirCOM_Driver_XP/: iarvircomport.inf
    ./: readme.txt
  group STM32F10xFWLib
    ../library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_tim1.c stm32f10x_usart.c
  group UARTs
    app/: uart.c uart.h
  group USB/Class
    app/: cd_class.c usb_desc.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    module/: usb_buffer.c usb_t9.c
    app/: usb_hooks.c
  group USB/HW
    module/: usb_hw.c
  group Vectors
    app/: stm32f10x_it.c stm32f10x_vector.c
