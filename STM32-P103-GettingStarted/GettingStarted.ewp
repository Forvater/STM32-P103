# IAR project GettingStarted.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCIncludePath2: ; board\; ..\library\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkIcfFile: config\STM32F10x_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EMB_FLASH
  ILINK.IlinkIcfFile: config\STM32F10x_FLASH.icf
  group (top)
    board/: cortexm3_macro.s
    ./: main.c stm32f10x_conf.h
  group Other
    config/: lnkarm_flash.xcl lnkarm_ram.xcl
    ./: readme.txt
  group STM32F10xFWLib
    ../library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_tim1.c
  group Vectors
    ./: stm32f10x_it.c stm32f10x_vector.c
