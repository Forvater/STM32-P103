# IAR project MassStorage.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: EMB_FLASH
  ICCARM.CCIncludePath2: ; app\; board\; module\; ..\library\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: MassStorage.out
  ILINK.IlinkIcfFile: config\STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    app/: main.c stm32f10x_conf.h
  group HD44780
    module/: drv_hd44780.c drv_hd44780_cnfg.h drv_hd44780_l.c
  group LUN
    app/: lun.c
  group LUN/SD/MMC
    app/: mmc.c mmc_dsk_desc.c STM32Fx_SPI2_cfg.h
  group Other
    config/: lnkarm_flash.xcl lnkarm_ram.xcl
    ./: readme.txt
  group STM32F10xFWLib
    ../library/src/: stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim1.c
  group USB/Class
    app/: scsi.c usb_desc.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    module/: usb_buffer.c usb_t9.c
    app/: usb_hooks.c
  group USB/HW
    module/: usb_hw.c
  group Vectors
    app/: stm32f10x_it.c stm32f10x_vector.c
