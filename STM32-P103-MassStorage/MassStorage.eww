<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MassStorage.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>USBMouse</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>USBMouse</project>
        <configuration>RAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


